# Keil uVision project LED_BLINK_PROJECT.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED_BLINK_PROJECT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LED_BLINK\Src\SERVICE;.\LED_BLINK\Src\MCAL\GPIO DRIVER;.\LED_BLINK\Src\MCAL\TIMER DRIVER;.\LED_BLINK\Src\MCAL\SYSTEM CONTROL DRIVER;.\LED_BLINK\Src\MCAL\INTERRUPT DRIVER;.\LED_BLINK\Src\HAL\LED Driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./LED_BLINK/Src/MCAL/GPIO DRIVER/: GPIO_program.c
    ./LED_BLINK/Src/MCAL/SYSTEM CONTROL DRIVER/: SYSCNTRL_program.c
    ./LED_BLINK/Src/MCAL/TIMER DRIVER/: TIMER0_program.c
    ./LED_BLINK/Src/MCAL/INTERRUPT DRIVER/: INTERRUPT_program.c
  group HAL
    ./LED_BLINK/Src/HAL/LED Driver/: led.c
  group APP
    ./LED_BLINK/Src/APP/: main.c app.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
